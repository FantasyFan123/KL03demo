# Keil uVision project platinum.uvprojx, settings and files
target KL02Z32-Flash (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFFE00,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: platinum_Flash
  AfterMake: fromelf --m32combined --output=outfile.s19  platinum_Flash.axf
  c flags: Optim=4
  c define: KEIL FREEDOM CMSIS
  c include: ..\common;..\drivers\tpm;..\drivers\uart;..\App;..\drivers\mcg;..\drivers\lptmr;..\drivers\smc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffe00 size 0x200
  memory RVCT10: RAM 0x20000000 size 0x600
  group App
    ../App/: freedom.h platinum.c
  group Common
    ../common/: arm_cm0.c io.c startup_MKL03Z4.s sysinit.c
  group drivers
    ../drivers/tpm/: tpm.c
    ../drivers/uart/: Retarget.c Serial.c uart.c
    ../drivers/mcg/: mcg_lite.c
    ../drivers/lptmr/: lptmr.c
    ../drivers/smc/: smc.c
